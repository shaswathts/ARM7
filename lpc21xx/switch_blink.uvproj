# Keil uVision project switch_blink.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: switch_blink +hex
  c flags: Optim=1
  group Source Group 1
    ./: 02_switch.c
